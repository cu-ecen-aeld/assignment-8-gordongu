## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Includes the scull module and all modules under misc-modules from ldd3 in the kernel image.
```
